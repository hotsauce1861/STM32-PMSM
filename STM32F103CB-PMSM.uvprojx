# Keil uVision project STM32F103CB-PMSM.uvprojx, settings and files
target PMSM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103CB-PMSM +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\User;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Display;.\Usart;.\SVPWM;.\Display;.\Event;.\Feedback;.\GwDebug;.\Math;.\Pid;.\Test;.\Foc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK-ARM
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c stm32f10x_conf.h
  group Doc
    ./Doc/: pin_map
  group Display
    ./Display/: display_driver.c display_device.c
  group SVPWM
    ./SVPWM/: svpwm_driver.c svpwm_driver.h svpwm_module.c
  group Usart
    ./Usart/: usart_driver.c
  group Event
    ./Event/: gw_event.c gw_timer.c gw_fifo.c gw_tasks.c gw_tasks.h
  group Feedback
    ./Feedback/: current.c encoder.c position.c
  group GwDebug
    ./GwDebug/: SDS.c SDS.h gw_log.h
  group Test
    ./Test/: test_svpwm.c test_encoder.c test_dispaly.c test_usart.c test_event.c
  group Math
    ./Math/: svpwm_math.c
  group Pid
    ./Pid/: pid_regulator.c pid_regulator.h
  group Foc
    ./Foc/: foc.c foc.h
